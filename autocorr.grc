options:
  parameters:
    generate_options: qt_gui
    id: short2byte
    output_language: python
    title: Short2byte
  states: {}

blocks:
- name: FAC_sz
  id: variable
  parameters:
    value: int(samp_rate/decimate)
  states: {}
- name: decimate
  id: variable
  parameters:
    value: '250'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ez/git/github/gnss-sdr/gnss-sdr/3_4_8_14_21_120s.bin
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '10.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*4
    type: short
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/(2*decimate)
    decim: decimate
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/(decimate)
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    ymax: '60'
    ymin: '-20'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    int_max: '60'
    int_min: '-10'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
