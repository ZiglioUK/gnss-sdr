options:
  parameters:
    generate_options: qt_gui
    id: short2byte
    output_language: python
    title: Short2byte
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ez/git/github/gnss-sdr/gnss-sdr/8bit_120s.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ez/git/github/gnss-sdr/gnss-sdr/3_4_8_14_21_120s.bin
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '10.0'
    vector_input: 'False'
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '128'
    ymin: '-128'
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_short_to_char_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_char_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
